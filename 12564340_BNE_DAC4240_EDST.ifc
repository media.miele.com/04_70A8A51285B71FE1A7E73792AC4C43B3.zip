Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 2832f1a4-79bb-4bbd-8e0c-44dab7630070, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:18:08+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12564340_BNE_DAC4240_EDST:28C4240S_BNE_12564340_DAC4240_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 1165 mm; Height: 196 mm; Depth: 500 mm
Pset_BuildingElementProxyCommon - Reference: 28C4240S_BNE_12564340_DAC4240_EDST; sets with these values: 2
